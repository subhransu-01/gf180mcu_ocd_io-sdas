v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {io_inv_2.sym} 70 -10 0 0 {name=x1}
