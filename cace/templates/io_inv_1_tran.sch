** sch_path: cace/templates/io_inv_1_tran.sch
**.subckt io_inv_1_tran
x1 Vin Vout VDD VSS io_inv_1
V1 VSS GND 0
V2 VDD GND CACE{vdd}
V3 Vin GND 0 PULSE(0 1.8 0 1n 1n 10n 20n)
C1 Vout GND CACE{cl} m=1
**** begin user architecture code

.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical




*.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}
.include CACE{DUT_path}
.temp CACE{temperature}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.option warn=1






.control
tran 0.1n CACE{Tmax}

meas tran tr1090 TRIG v(Vout) VAL='0.1*CACE{vdd} RISE=1 TARG v(Vout) VAL='0.9*CACE{vdd} RISE=1
meas tran tf9010 TRIG v(Vout) VAL='0.9*CACE{vdd} FALL=1 TARG v(Vout) VAL='0.1*CACE{vdd} FALL=1

set wr_singlescale

wrdata CACE{simpath}/CACE{filename}_CACE{N}.data V(Vout) V(Vin)
.endc



**** end user architecture code
**.ends
.GLOBAL GND
.end
